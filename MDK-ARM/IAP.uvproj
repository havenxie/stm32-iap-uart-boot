# Keil uVision project IAP.uvproj, settings and files
target STM32-IAP_HD_VL (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-IAP_HD_VL +hex
  AfterMake: .\..\Binary\hextobin.bat
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STM32100E_EVAL, STM32F10X_HD_VL, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\CORE;..\MDK-ARM;..\STM32F10x_FWLib\inc;..\IAP\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group IAP
    ../IAP/inc/: iap_config.h
    ../IAP/src/: common.c iap.c stmflash.c ymodem.c
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_hd_vl.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
  group Doc
    ../: README.md
target STM32-IAP_XL (ARM-ADS)
  device: STM32F103ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-IAP_XL +hex
  AfterMake: .\..\Binary\hextobin.bat
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STM3210E_EVAL, STM32F10X_XL, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\CORE;..\MDK-ARM;..\STM32F10x_FWLib\inc;..\IAP\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3000
  memory RVCT9: RAM 0x20000000 size 0x18000
target STM32-IAP_MD_VL (ARM-ADS)
  device: STM32F100VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-IAP_MD_VL +hex
  AfterMake: .\..\Binary\hextobin.bat
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STM32100B_EVAL, STM32F10X_MD_VL, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\CORE;..\MDK-ARM;..\STM32F10x_FWLib\inc;..\IAP\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3000
  memory RVCT9: RAM 0x20000000 size 0x2000
target STM32-IAP_CL (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM32-IAP_CL +hex
  AfterMake: .\..\Binary\hextobin.bat
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL, USE_STM3210C_EVAL
  c include: ..\inc;..\CORE;..\MDK-ARM;..\STM32F10x_FWLib\inc;..\IAP\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3000
  memory RVCT9: RAM 0x20000000 size 0x10000
target STM32-IAP_HD (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: STM32-IAP_HD +hex
  AfterMake: ".\..\Binary\hextobin.bat"
  c flags: OneElfS=1 wLevel=2
  c define: USE_STM3210E_EVAL, STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\STM32F10x_FWLib\inc;..\CORE;..\MDK-ARM;..\IAP\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3000
  memory RVCT9: RAM 0x20000000 size 0x10000
target STM32-IAP_MD (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-IAP_MD +hex
  AfterMake: .\..\Binary\hextobin.bat
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STM3210B_EVAL, STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\CORE;..\MDK-ARM;..\STM32F10x_FWLib\inc;..\IAP\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3000
  memory RVCT9: RAM 0x20000000 size 0x5000
